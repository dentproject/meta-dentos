
hostname = "dentOS"